## kernel/security/GomoLSM/Kconfig
```kconfig
config     SECURITY_GOMOLSM
   bool     "GomoLSM support"
   depends on SECURITY
   default     n
   help
        introduction of GomoLSM
```
